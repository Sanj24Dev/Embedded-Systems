	AREA RESET, CODE, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM
	LDR R0,[R0]
	LDR R1,=DEN
	LDR R1,[R1]
	MOV R2,#0
	
DIV	CMP R0,R1
	BLO STORE
	SUB R0,R1
	ADD R2,#1
	B DIV
	
STORE
	LDR R3,=RES
	STR R2,[R3]
	
STOP	B STOP

NUM DCD 10
DEN DCD 4
	AREA MYDATA, DATA, READWRITE
RES DCD 0
	END
	
	