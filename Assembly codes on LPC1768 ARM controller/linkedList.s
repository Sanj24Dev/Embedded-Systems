	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=HEAD
	
	MOV R1,#4
	BL INSERT
	
	MOV R1,#2
	BL INSERT
	
	MOV R1,#10
	BL INSERT
	
	BL DISPLAY	;SHOWN IN R5
	
	MOV 
	BL INSERT
	
	;BL DELETE
	
	
STOP
	B STOP
	
INSERT
	MOV R3,R0
MOVE
	LDR R4,[R3],#4
	CMP R4,#0
	BNE MOVE
	STR R1,[R3,#-4]
	BX LR
	
DISPLAY
	MOV R3,R0
MOVED
	LDR R5,[R3],#4
	CMP R5,#0
	BNE MOVED
	BX LR

	AREA MYDATA, DATA, READWRITE
HEAD DCD 0
	END