;NO OF ONES IN BINARY EQ	
	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	MOV R0,#0XCF
	MOV R1,#0	;Q
	MOV R2,#0	;COUNT
	
DIV CMP R0,#2
	BLO DOWN
	SUB R0,#2
	ADD R1,#1
	B DIV
	
DOWN
	CMP R0,#1
	BNE DOWN2
	ADD R2,#1
DOWN2
	MOV R0,R1
	MOV R1,#0
	CMP R0,#0
	BNE DIV
	
STOP
	B STOP
	
NUM DCD 0XCF
	AREA MYDATA, DATA, READWRITE
RES DCD 0
	END