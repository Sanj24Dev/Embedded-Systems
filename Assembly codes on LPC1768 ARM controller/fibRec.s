	AREA RESET, CODE, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=DEST
	LDR R5,=COUNT
	LDR R5,[R5]
	MOV R6,#0	;FINAL ANSWER
	MOV R1,#0
	MOV R2,#1
	BL FIB
		
	STR R2,[R0]
STOP
	B STOP
	
FIB
	PUSH {R14}
	CMP R5,#2
	BEQ DOWN
	SUB R5,#1
	BL FIB
	ADD R3,R2,R1
	MOV R1,R2
	MOV R2,R3	
DOWN
	POP {R14}
	BX LR
	
	
COUNT DCD 8
	AREA MYDATA, DATA, READWRITE
DEST DCD 0
	END