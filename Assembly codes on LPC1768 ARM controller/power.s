;Find x raised to y using recursion.

	AREA RESET, CODE, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=X
	LDR R1,=Y
	LDR R0,[R0]
	LDR R1,[R1]
	MOV R2,#1
	
	BL POWER
STORE
	LDR R3,=RESULT
	STR R2,[R3]
STOP
	B STOP
	
POWER
	PUSH {R9,LR}
	;MOV R4,R1
	CMP R1,#0
	BEQ DOWN
	SUB R1,#1
	BL POWER
	MUL R2,R0
DOWN
	POP {R9,LR}
	BX LR
	
X DCD 5
Y DCD 2
	AREA MYDATA, DATA, READWRITE
RESULT DCD 0
	END
	