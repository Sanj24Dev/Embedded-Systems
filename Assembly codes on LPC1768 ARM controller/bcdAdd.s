	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=N1
	LDR R1,=N2
	LDR R0,[R0]
	LDR R1,[R1]
	MOV R2, #0XF
	MOV R3, #0	;RES
	MOV R7, #0	;CARRY
	MOV R8,#0	;SHIFT COUNTER
	MOV R9,#8
	
SUM	AND R4,R0,R2
	AND R5, R1, R2
	ADD R6,R4,R5
	ADD R6,R7
	MOV R7,#0
	CMP R6,#9
	BLS DOWN
	SUB R6,#10
	MOV R7,#1
DOWN
	LSL R6,R8
	ADD R8,#4
	ORR R3,R6
	LSR R0,#4
	LSR R1,#4
	SUB R9,#1
	CMP R9,#0
	BNE SUM
	
	LDR R0,=RES
	STR R3,[R0]
STOP
	B STOP

N1 DCD 0X99
N2 DCD 0X99
	AREA MYDATA, DATA, READWRITE
RES DCD 0
	END