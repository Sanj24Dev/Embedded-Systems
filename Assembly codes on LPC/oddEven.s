	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R6,=SRC
	LDR R0,[R6],#4
	MOV R1,#0	;Q
	MOV R2,#0	;ODD
	MOV R3,#5
	MOV R4,#0	;EVEN
	
DIV CMP R0,#2
	BLS DOWN
	SUB R0,#2
	ADD R1,#1
	B DIV
	
DOWN
	CMP R0,#1
	ADDEQ R2,#1
	ADDNE R4,#1
	LDR R0,[R6],#4
	SUB R3,#1
	CMP R3,#0
	BNE DIV
	
STOP
	B STOP
SRC DCD 1,2,3,4,5
	END