		AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM1
	LDR R0,[R0]
	
	BL BCDtoHEX
	MOV R2,R1
	
	LDR R0,=NUM2
	LDR R0,[R0]
	
	BL BCDtoHEX
	MOV R3,R1
	
	MUL R4,R3,R2
	
	BL HEXtoBCD
	LDR R0,=RES
	STR R1,[R0]
	
STOP
	B STOP
	
BCDtoHEX
	MOV R3,#10
	MOV R4,#1
	MOV R5,#0XF
	
DIG	AND R6,R0,R5
	MLA R1,R6,R4,R1
	MUL R4,R3
	LSR R0,#4
	CMP R0,#0
	BNE DIG
	BX LR
	
HEXtoBCD
	MOV R1,0
	MOV R2,0
	MOV R3,#0XF
	
DIV CMP R3,0
	BLS DOWN
	SUB R3,#10
	ADD R2,#1
	B DIV
DOWN
	
	
NUM1 DCD 0X11
NUM2 DCD 0X22
	AREA MYDATA, DATA, READWRITE
RES DCD 0
	END