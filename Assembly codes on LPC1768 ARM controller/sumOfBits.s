	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM
	LDR R0,[R0]
	
GETBIT
	CMP R0,#2
	BLO SUM
	SUB R0,#2
	ADD R1,#1
	B GETBIT

SUM
	ADD R3,R0
	MOV R0,R1
	MOV R1,#0
	CMP R0,#0
	BNE GETBIT

	LDR R0,=RES
	STR R3,[R0]
	
STOP
	B STOP
	
NUM DCD 0XCF
	AREA MYDATA, DATA, READWRITE
RES DCD 0
	END