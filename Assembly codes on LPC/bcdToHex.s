	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=BCD
	LDR R5,[R0]
	MOV R1,#0	;ANSWER
	MOV R2,#1	;POWER
	MOV R3,#0XA	;FACTOR
	MOV R4,#0XF
	
UP	AND R6,R5,R4
	MLA R1,R6,R2,R1
	MUL R2,R3
	LSR R5,#4
	CMP R5,#0
	BNE UP
	
	LDR R0,=RES
	STR R1,[R0]
STOP
	B STOP
BCD DCD 12
	AREA MYDATA,DATA,READWRITE
RES DCD 0
	END