	AREA RESET, DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE, CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM1
	LDR R1,=NUM2
	LDR R0,[R0]
	LDR R1,[R1]
	MOV R2,#0
	
	BL GCD
	
	MOV R4, R0
	LDR R0,=NUM1
	LDR R1,=NUM2
	LDR R0,[R0]
	LDR R1,[R1]
	MOV R2,#0
	MUL R0,R1
DIV2
	CMP R0,R4
	BLO DONE2
	SUB R0,R4
	ADD R2,#1
	B DIV2
	
DONE2

STOP 
	B STOP
	
GCD PUSH {R14}
DIV	CMP R0,R1
	BLO DONE
	SUB R0,R1
	B DIV
DONE
	MOV R2, R1
	MOV R1, R0
	MOV R0, R2
	CMP R1,#0
	BEQ DOWN	
	BL GCD
	
DOWN
	POP {R14}
	BX LR
	
NUM1 DCD 45
NUM2 DCD 15
	
	END