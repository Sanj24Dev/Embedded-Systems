	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=HEX
	LDR R1,[R0]
	MOV R2,#0	;Q
	MOV R3,#0XA
	MOV R4,R1
	MOV R5,#0	;PACKED BCD
	MOV R6,#0	;SHIFT COUNTER

DIV	CMP R1,R3
	BLS DONE
	SUB R1,R3
	ADD R2,#1
	B DIV
	
DONE
	LSL R1,R6
	ADD R6,#4
	ORR R5,R1
	MOV R1,R2
	MOV R2,#0
	CMP R1,#0
	BNE DIV
	
	LDR R0,=RES
	STR R5,[R0]
	
STOP
	B STOP
HEX DCD 0Xff
	AREA MYDATA, DATA, READWRITE
RES DCD 0
	END